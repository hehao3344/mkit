# IAR project rf_device.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; rf; ..\STM8S_StdPeriph_Driver\inc; ..\STM8S_StdPeriph_Driver\src; ..\User\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: rf_device.srec
  ILINK.IlinkOutputFile: rf_device.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group crypto
    crypto/: aes.c aes_api.c crypto_api.c packet.c rsa.c rsa_api.c
  group flash
    flash/: flash_eeprom.c
  group json
    json/: cJson.c
  group library
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c
  group protocol
    protocol/: protocol.c
  group rf
    rf/: sx1276.c sx1276_hal.c system_config.c
  group sys_mgr
    sys_mgr/: sys_mgr.c time1.c
  group user
    ../User/: main.c stm8s_it.c
